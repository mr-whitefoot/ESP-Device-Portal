#pragma once

// Разбор десятичного числа из строки: пробелы/табуляции, знак, цифры, одна
// точка, цифры. На первом постороннем символе разбор останавливается и
// возвращается накопленное. Экспоненты, hex, inf и nan не понимает.
//
// Чистая логика без Arduino -- проверяется нативными тестами. Зачем она нужна:
// в прошивке на ней построена собственная atof (см. src/main.cpp), а libc-шная
// тянет strtod со всем его хозяйством ради чисел, которых в портале нет.
//
// Имя не atof намеренно: на хосте тест не должен спорить с настоящим libc.

static inline double parseDecimal(const char* s) {
  while (*s == ' ' || *s == '\t') s++;
  bool neg = false;
  if (*s == '-') {
    neg = true;
    s++;
  } else if (*s == '+') {
    s++;
  }
  double v = 0, scale = 1;
  bool frac = false;
  for (;; s++) {
    if (*s >= '0' && *s <= '9') {
      if (!frac) {
        v = v * 10 + (*s - '0');
      } else if (scale < 1e18) {
        // Дальше 18 знаков после точки double всё равно ничего не прибавит,
        // а scale без этого предела дорос бы до бесконечности на длинной строке.
        v = v * 10 + (*s - '0');
        scale *= 10;
      }
    } else if (*s == '.' && !frac) {
      frac = true;
    } else {
      break;
    }
  }
  v /= scale;
  return neg ? -v : v;
}
