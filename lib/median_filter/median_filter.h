#pragma once
#include <stdint.h>

// Медианный фильтр показаний датчика: скользящее окно последних N значений,
// на выходе медиана по фактически набранным.
//
// Чистая логика без Arduino -- проверяется нативными тестами.
//
// Прежняя реализация (проект ESP-Temp-sensor-DS1820B-Portal) держала не окно,
// а отсортированный набор из девяти чисел, где новое значение вытесняло либо
// минимум (если оно больше всех), либо максимум (иначе). Возраст значений не
// учитывался вовсе, поэтому:
//   - нули начального состояния оставались частью выборки и участвовали в
//     медиане наравне с показаниями;
//   - при отрицательной температуре фильтр первые пять чтений выдавал ровно
//     0 °C, а не измеренное значение;
//   - выброс, попавший в середину отсортированного набора, мог остаться в нём
//     навсегда: вытесняются только края.
// Окно с медианой по набранному свободно от всех трёх.

template <uint8_t N>
class MedianFilter {
  static_assert(N > 0, "окно фильтра не может быть пустым");

 public:
  // Значения вне диапазона отбрасываются. У DS18B20 ошибки приходят теми же
  // числами, что и показания (-127 обрыв линии, -128 ошибка CRC), и без
  // проверки попадали бы в выборку наравне с настоящей температурой.
  MedianFilter(float min, float max) : min_(min), max_(max) {}

  void reset() {
    count_ = 0;
    next_ = 0;
  }

  // false -- значение отброшено как недостоверное, окно не тронуто.
  bool add(float value) {
    // Сравнение "в диапазоне", а не "вне": NaN проваливает любое сравнение,
    // и в такой форме отбрасывается заодно.
    if (!(value >= min_ && value <= max_)) return false;

    buf_[next_] = value;
    next_ = (uint8_t)((next_ + 1) % N);
    if (count_ < N) count_++;
    return true;
  }

  // Есть ли хоть одно достоверное значение. Пока false, показывать и
  // публиковать нечего: ноль здесь означал бы "0 °C", а не "не знаю".
  bool ready() const { return count_ != 0; }

  uint8_t count() const { return count_; }

  // Медиана по набранным значениям. До заполнения окна считается по тому,
  // что есть, поэтому результат осмыслен с первого же чтения. При чётном
  // числе значений -- среднее двух средних.
  float value() const {
    if (!count_) return 0.0f;

    float sorted[N];
    for (uint8_t i = 0; i < count_; i++) sorted[i] = buf_[i];

    // Сортировка вставками: N порядка десятка, и квадратичность здесь дешевле
    // по флешу, чем что-либо умнее.
    for (uint8_t i = 1; i < count_; i++) {
      float v = sorted[i];
      uint8_t j = i;
      while (j && sorted[j - 1] > v) {
        sorted[j] = sorted[j - 1];
        j--;
      }
      sorted[j] = v;
    }

    uint8_t mid = (uint8_t)(count_ / 2);
    if (count_ % 2) return sorted[mid];
    return (sorted[mid - 1] + sorted[mid]) / 2.0f;
  }

 private:
  const float min_;
  const float max_;
  float buf_[N];
  uint8_t count_ = 0;
  uint8_t next_ = 0;
};
